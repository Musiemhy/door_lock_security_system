<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\door_lock_security_system.ewp</path>
    </project>
    <batchBuild />
</workspace>
